options:
  parameters:
    generate_options: qt_gui
    id: web_message_widgets
    output_language: python
    title: '''Message widgets'''
  states: {}

blocks:
- name: check
  id: variable_qtgui_msgcheckbox
  parameters:
    gui_hint: 0,3
    initPressed: 'False'
    label: '''Check'''
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: dial
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: 1,0
    label: '''Dial'''
    maximum: '100'
    minimum: '0'
    showvalue: 'False'
    type: int
    value: '25'
  states: {}
- name: qtgui_dialgauge_0
  id: qtgui_dialgauge
  parameters:
    gui_hint: 2,2
    label: '''Gauge'''
    maximum: '100'
    minimum: '0'
    type: int
    value: '0'
  states: {}
- name: qtgui_levelgauge_0
  id: qtgui_levelgauge
  parameters:
    gui_hint: 2,1
    label: '''Level'''
    maximum: '100'
    minimum: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: switch
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 0,2
    initPressed: 'False'
    label: '''Switch'''
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: toggle
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: 0,1
    initPressed: 'False'
    label: '''Toggle'''
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: tuner
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 1,1,1,2
    lbl: '''Tuner'''
    maxFreqHz: 1700e6
    minFreqHz: 30e6
    value: 100e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.intern('state'), pmt.from_bool(True))
    period: '500'
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.intern('value'), pmt.from_double(63.0))
    period: '300'
  states: {}
- name: blocks_message_strobe_2
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.intern('angle'), pmt.from_double(135.0))
    period: '300'
  states: {}
- name: blocks_message_strobe_3
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.intern('radius'), pmt.from_double(55.0))
    period: '300'
  states: {}
- name: blocks_message_strobe_4
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.cons(pmt.to_pmt({''az'': 120.0, ''el'': 35.0}), pmt.PMT_NIL)'
    period: '300'
  states: {}
- name: edit
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 1,3
    key: '''cmd'''
    label: '''Edit'''
    type: string
    value: '''hello'''
  states: {}
- name: push
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: 0,0
    label: '''Send'''
    msgName: '"pressed"'
    type: int
    value: '42'
  states: {}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    fullNeedle: '1'
    gui_hint: 2,3
    min_size: '250'
    name: '''Compass'''
    usemsg: 'True'
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: 2,0
    label: '''LED'''
  states: {}
- name: variable_qtgui_azelplot_0
  id: variable_qtgui_azelplot
  parameters:
    gui_hint: 3,1
    label: '''AzEl'''
  states: {}
- name: variable_qtgui_distanceradar_0
  id: variable_qtgui_distanceradar
  parameters:
    gui_hint: 3,0
    label: '''Radar'''
    ticklabels: '[''20'', ''40'', ''60'', ''80'', ''100'']'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, qtgui_ledindicator_0, state]
- [blocks_message_strobe_1, strobe, qtgui_dialgauge_0, value]
- [blocks_message_strobe_1, strobe, qtgui_levelgauge_0, value]
- [blocks_message_strobe_2, strobe, qtgui_compass_0, angle]
- [blocks_message_strobe_3, strobe, variable_qtgui_distanceradar_0, radius]
- [blocks_message_strobe_4, strobe, variable_qtgui_azelplot_0, azel]
- [check, state, blocks_message_debug_0, print]
- [dial, value, blocks_message_debug_0, print]
- [edit, msg, blocks_message_debug_0, print]
- [push, pressed, blocks_message_debug_0, print]
- [switch, state, blocks_message_debug_0, print]
- [toggle, state, blocks_message_debug_0, print]
- [tuner, valueout, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
