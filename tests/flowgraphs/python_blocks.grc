options:
  parameters:
    generate_options: qt_gui
    id: web_python_blocks
    output_language: python
    title: '''Embedded Python'''
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    label: '''Python block gain'''
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: helpers.tone()
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Gain block written in the browser: multiplies by a gain and counts calls.
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Scale the input"""

          def __init__(self, gain=2.0):
              gr.sync_block.__init__(self, name='Web gain', in_sig=[np.complex64], out_sig=[np.complex64])
              self.gain = gain

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0] * self.gain
              return len(output_items[0])
    gain: gain
  states: {}
- name: helpers
  id: epy_module
  parameters:
    source_code: |
      def tone():
          return 2500.0
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '''After Python block'''
    size: '256'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: 'print(''snippet: flow graph started'')'
    section: main_after_start
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
